# IAR project display.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT
  ICCARM.CCIncludePath2: ..\..\..\; ..\; ..\inc; ..\driverlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: display.out
  ILINK.IlinkIcfFile: display.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: cfaf128x128x16.c main.c startup_ewarm.c system_tm4c1294ncpdt.c
    ../driverlib/ewarm/Exe/: driverlib.a
    ../grlib/Debug/Exe/: grlib.a
