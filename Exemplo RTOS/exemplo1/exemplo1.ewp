# IAR project exemplo1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; ARMCM4_FP; PART_TM4C1294NCPDT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\; ..\; ..\driverlib; ..\Device\ARM\ARMCM4\Include; ..\CMSIS\RTOS2\Include; ..\CMSIS\RTOS2\RTX\Include; ..\CMSIS\RTOS2\RTX\Library\IAR\IDE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: exemplo1.bin
  ILINK.IlinkOutputFile: exemplo1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: driverleds.c driverleds.h main.c mydelay.s RTX_Config.c rtx_lib.c startup_tm4c1294.s system_tm4c1294.c
    ../driverlib/ewarm/Exe/: driverlib.a
    ../CMSIS/RTOS2/RTX/Library/IAR/: RTX_CM4F.a
